inherit pypi setuptools3
require python-pyqrcode.inc
