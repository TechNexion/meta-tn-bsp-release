inherit pypi setuptools
require python-pyqrcode.inc

