PYQT_MODULES_append = " QtDBus QtSvg"

DEPENDS += "dbus qtsvg"

RDEPENDS_${PN}_append = " dbus qtsvg"
