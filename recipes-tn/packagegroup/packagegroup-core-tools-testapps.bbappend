# ltp takes a great deal of space so remove it
RDEPENDS:${PN}:remove = " ltp \
"

