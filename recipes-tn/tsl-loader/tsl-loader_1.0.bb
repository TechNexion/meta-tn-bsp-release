require tsl-loader.inc

SRCSERVER = "git://github.com/TechNexion-customization/rescue-loader.git;protocol=https"
SRCBRANCH = "rel:rescue_v2021.01.30"
SRCREV = "a509febfd1c33cb4a1224d9ad89be6500161276b"
