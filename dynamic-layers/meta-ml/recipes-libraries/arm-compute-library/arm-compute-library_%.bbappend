SCONS_MAXLINELENGTH = ""
