SRC_URI_append_rescue = " file://0001-u-boot-Set-CONFIG_SYS_BOOTM_LEN-in-imx_env.h-for-TSL.patch"
