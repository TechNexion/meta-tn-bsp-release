COMPATIBLE_MACHINE = "(mx8mp-nxp-bsp)"