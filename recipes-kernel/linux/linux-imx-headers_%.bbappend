DEPENDS += "rsync-native"

