FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Fix-build-errors-on-Yocto-3.2-Gatesgarth.patch"

