# Copyright 2019-20 NXP
# Copyright (C) 2024 TechNexion Ltd.
# Released under the MIT license (see COPYING.MIT for the terms)

RDEPENDS:${PN}:append = " \
    packagegroup-qt6-demos \
    "
