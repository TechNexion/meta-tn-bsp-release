RDEPENDS:${PN}-utils:remove = " xinput-calibrator"
