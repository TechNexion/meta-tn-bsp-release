SRC_URI:append:mx6-nxp-bsp = " file://daemon.conf file://default.pa \
                       file://pulseaudio-remove-the-control-for-speaker-headphone-widge.patch \
"
SRC_URI:append:mx8-nxp-bsp = " file://daemon.conf file://default.pa \
                       file://pulseaudio-remove-the-control-for-speaker-headphone-widge.patch \
"