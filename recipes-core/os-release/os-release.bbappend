
OS_RELEASE_FIELDS += "BUILD_ID"

do_compile[nostamp] = "1"
do_install[nostamp] = "1"
