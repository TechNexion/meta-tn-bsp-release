# Remove for tn-container build because of meta-imx/recipes-connectivity/openssl/openssl_1.%.bbappend
PACKAGECONFIG_remove_cntnr = "cryptodev-linux"
